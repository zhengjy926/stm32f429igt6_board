# Keil uVision project stm32f429igt6_board.uvprojx, settings and files
target Target_1 (6230000::V6.23::ARMCLANG)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32f429igt6_board +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: STM32F429xx,USE_FULL_LL_DRIVER
  c include: ..\third_party\CMSIS_6\CMSIS\Core\Include;..\third_party\CMSIS_6\CMSIS\Core\Include\m-profile;..\third_party\stm32f4xx-hal-driver\Inc;..\third_party\stm32f4xx-hal-driver\Inc\Legacy;..\third_party\cmsis-device-f4\Include;..\drivers;..\board;..\kernel;..\libs
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group app
    ../app/: main.c
  group service
    ../services/: indicator.c
  group board
    ../board/: board.c stm32_it.c startup_stm32f429xx.s
  group drivers
    ../drivers/gpio/: gpio_stm32.c
    ../drivers/led/: led_gpio.c
  group kernel
    ../kernel/: device.c
  group third_party/stm32f4xx-hal-driver
    ../third_party/stm32f4xx-hal-driver/Src/: stm32f4xx_ll_exti.c stm32f4xx_ll_gpio.c stm32f4xx_ll_rcc.c stm32f4xx_ll_utils.c
  group third_party/cmsis-device-f4
    ../third_party/cmsis-device-f4/Source/Templates/: system_stm32f4xx.c
